# Keil uVision project Voice_ADC.uvproj, settings and files
target QCopterMV (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Voice_ADC
  c flags: Optim=1
  c define: STM32F40XX, USE_STDPERIPH_DRIVER, __FPU_PRESENT=1, __FPU_USED =1, ARM_MATH_CM4, __CC_ARM
  c include: ..\;..\Libraries\CMSIS;..\Libraries\CMSIS\startup;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\STM32F4xx_StdPeriph_Driver\src;..\Program;..\Libraries\FATFS
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../Libraries/CMSIS/startup/: startup_stm32f4xx.s
  group CMSIS
    ../Libraries/CMSIS/: system_stm32f4xx.c
  group Library
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_dma.c stm32f4xx_adc.c stm32f4xx_gpio.c stm32f4xx_sdio.c stm32f4xx_usart.c
  group Main Program
    ../Program/: Voice_ADC_Main.c
  group Module Driver
    ../Program/: stm32f4_ADC.c stm32f4_DELAY.c stm32f4_GPIO.c stm32f4_LED.c stm32f4_USART.c StringConvert.c stm32f4_SDIO.c
  group Documentation
    ../Documents/: History.txt Readme.txt
  group FatFS
    ../Libraries/FATFS/: diskio.c ff.c
